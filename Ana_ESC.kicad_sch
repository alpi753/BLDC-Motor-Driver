File: Ana_ESC.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Footprints prepared, first pcb project created.
